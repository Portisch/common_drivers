## arch/arm64/configs/amlogic_multidisplay.defconfig
```kconfig
#aml-media.ko
CONFIG_AMLOGIC_LCD=y
CONFIG_AMLOGIC_BACKLIGHT=y
CONFIG_AMLOGIC_LCD_MIPI_DSI=y
```
